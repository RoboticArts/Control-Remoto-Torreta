# Keil uVision project plantilla_ITM_debug.uvprojx, settings and files
target plantilla_ITM_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: plantilla_ITM_debug
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .;..\terceros\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include;..\terceros\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include;..\terceros\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\terceros\STM32F4-Discovery_FW_V1.1.0\Utilities\STM32F4-Discovery;..\terceros\binario;..\terceros\lcd;..\terceros\adc;..\terceros\accelerometer;..\terceros\hyperion
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --show_full_path
  group User
    ./: system_stm32f4xx.c main.c stm32f4xx_it.c fputc_debug.c
  group STM32F4-Discovery
    ../terceros/STM32F4-Discovery_FW_V1.1.0/Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../terceros/STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group MDK-ARM
    ../terceros/STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Binario
    ../terceros/binario/: binario.c
  group LCD
    ../terceros/lcd/: tm_stm32f4_hd44780.c tm_stm32f4_gpio.c tm_stm32f4_timer_properties.c tm_stm32f4_delay.c
  group ADC
    ../terceros/adc/: tm_stm32f4_adc.c
    ../terceros/STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c
  group Acelerometro
    ../terceros/accelerometer/: tm_stm32f4_lis302dl_lis3dsh.c tm_stm32f4_spi.c
    ../terceros/STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_spi.c
  group MiLibreria
    ../terceros/hyperion/: hyperion.c
software components: CMSIS:CORE 4.1.0
